# Keil uVision project GD32F470.uvprojx, settings and files
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\Hardware\timer;..\Hardware\pwm;..\Hardware\dma
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Hardware
    ../Hardware/led/: bsp_led.c bsp_led.h
    ../Hardware/usart/: bsp_usart.c bsp_usart.h
    ../Hardware/key/: bsp_key.c bsp_key.h
    ../Hardware/timer/: bsp_basic_timer.c bsp_basic_timer.h
    ../Hardware/pwm/: bsp_pwm.c bsp_pwm.h
    ../Hardware/dma/: bsp_dma.c bsp_dma.h
  group User
    ../User/: gd32f4xx_it.c main.c systick.c sys.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../Doc/: readme.txt
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_dma.c
    ../../Key_LED/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c
